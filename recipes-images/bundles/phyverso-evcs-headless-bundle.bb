require recipes-images/bundles/phytec-base-bundle.inc
RAUC_SLOT_rootfs ?= "phyverso-evcs-image"
